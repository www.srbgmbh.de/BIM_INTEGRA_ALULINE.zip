Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: d802a977-3caa-4327-8645-8eb4b5602948, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Gemeinsam genutzte Koordinaten]
File name: INTEGRA ALULINE 100 - white.ifc
Time: 2025-01-29T09:11:13+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (DEU) - IFC 25.1.0.44

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: INTEGRA ALULINE 100 - white:INTEGRA ALULINE 100, INTEGRA ALULINE 100 - white:INTEGRA ALULINE 100:2518117
In: Default
Type - Material: Vorgabe(1)
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: INTEGRA ALULINE 100; sets with these values: 2
